/*
 * lws-api-test-gencrypto - lws-genrsa
 *
 * Written in 2010-2018 by Andy Green <andy@warmcat.com>
 *
 * This file is made available under the Creative Commons CC0 1.0
 * Universal Public Domain Dedication.
 */

 #include <libwebsockets.h>
 #include <stdlib.h>
 
/*
 * The PKCS#1 v1.5 data encrypt / decrypt class of the generic RSA apis is
 * only available on some backends; GnuTLS, mbedTLS v3 and BearSSL fail
 * those calls with their own logs, so subtests using them are skipped there
 */
#if !defined(LWS_WITH_GNUTLS) && \
    !(defined(LWS_WITH_MBEDTLS) && defined(MBEDTLS_VERSION_NUMBER) && \
      MBEDTLS_VERSION_NUMBER >= 0x03000000) && \
    !defined(LWS_WITH_BEARSSL)
#define GENRSA_HAS_PKCS1_DATAOPS
#endif

/*
 * OAEP-mode data encrypt / decrypt is available on the PKCS#1 data-op
 * backends and on BearSSL (which provides OAEP pieces only)
 */
#if defined(GENRSA_HAS_PKCS1_DATAOPS) || defined(LWS_WITH_BEARSSL)
#define GENRSA_HAS_OAEP
#endif

/*
 * Every backend apart from GnuTLS and mbedTLS v3 can generate keypairs and
 * drive the sign / verify apis the ctx liveness fence probes with
 */
#if !defined(LWS_WITH_GNUTLS) && \
    !(defined(LWS_WITH_MBEDTLS) && defined(MBEDTLS_VERSION_NUMBER) && \
      MBEDTLS_VERSION_NUMBER >= 0x03000000)
#define GENRSA_HAS_KEYGEN_SIGNVERIFY
#endif

static void
test_genrsa_prepare_public_elements(struct lws_gencrypto_keyelem *dest,
				    const struct lws_gencrypto_keyelem *src)
{
	memset(dest, 0, sizeof(*dest) * LWS_GENCRYPTO_RSA_KEYEL_COUNT);
	dest[LWS_GENCRYPTO_RSA_KEYEL_E] = src[LWS_GENCRYPTO_RSA_KEYEL_E];
	dest[LWS_GENCRYPTO_RSA_KEYEL_N] = src[LWS_GENCRYPTO_RSA_KEYEL_N];
}

#if defined(GENRSA_HAS_PKCS1_DATAOPS)
static int
test_genrsa_roundtrips(struct lws_context *context)
 {
     static const uint8_t priv_plain[] = "private encrypt roundtrip";
     static const uint8_t pub_plain[] = "public encrypt roundtrip";
     struct lws_genrsa_ctx priv_ctx, pub_ctx;
     struct lws_gencrypto_keyelem el[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
     struct lws_gencrypto_keyelem pub_el[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
     uint8_t *cipher = NULL, *plain = NULL;
     size_t key_bytes;
     int n;
     int ret = 1;
 
     memset(&priv_ctx, 0, sizeof(priv_ctx));
     memset(&pub_ctx, 0, sizeof(pub_ctx));
     memset(el, 0, sizeof(el));
     memset(pub_el, 0, sizeof(pub_el));
 
     if (lws_genrsa_new_keypair(context, &priv_ctx, LGRSAM_PKCS1_1_5, el,
                    2048)) {
         lwsl_err("%s: lws_genrsa_new_keypair failed\n", __func__);
         goto bail;
     }
 
     pub_el[LWS_GENCRYPTO_RSA_KEYEL_E] = el[LWS_GENCRYPTO_RSA_KEYEL_E];
     pub_el[LWS_GENCRYPTO_RSA_KEYEL_N] = el[LWS_GENCRYPTO_RSA_KEYEL_N];
 
     if (lws_genrsa_create(&pub_ctx, pub_el, context, LGRSAM_PKCS1_1_5,
                   LWS_GENHASH_TYPE_UNKNOWN)) {
         lwsl_err("%s: lws_genrsa_create public ctx failed\n", __func__);
         goto bail;
     }
 
     key_bytes = el[LWS_GENCRYPTO_RSA_KEYEL_N].len;
     cipher = malloc(key_bytes);
     plain = malloc(key_bytes);
     if (!cipher || !plain) {
         lwsl_err("%s: OOM allocating test buffers\n", __func__);
         goto bail;
     }
 
     n = lws_genrsa_private_encrypt(&priv_ctx, priv_plain,
                        sizeof(priv_plain) - 1, cipher);
     if (n < 0) {
         lwsl_err("%s: lws_genrsa_private_encrypt failed\n", __func__);
         goto bail;
     }
 
     n = lws_genrsa_public_decrypt(&pub_ctx, cipher, (size_t)n, plain,
                       key_bytes);
     if (n != (int)(sizeof(priv_plain) - 1) ||
         lws_timingsafe_bcmp(plain, priv_plain, sizeof(priv_plain) - 1)) {
         lwsl_err("%s: private->public roundtrip mismatch\n", __func__);
         goto bail;
     }
 
     n = lws_genrsa_public_encrypt(&pub_ctx, pub_plain, sizeof(pub_plain) - 1,
                       cipher);
     if (n < 0) {
         lwsl_err("%s: lws_genrsa_public_encrypt failed\n", __func__);
         goto bail;
     }
 
     n = lws_genrsa_private_decrypt(&priv_ctx, cipher, (size_t)n, plain,
                        key_bytes);
     if (n != (int)(sizeof(pub_plain) - 1) ||
         lws_timingsafe_bcmp(plain, pub_plain, sizeof(pub_plain) - 1)) {
         lwsl_err("%s: public->private roundtrip mismatch\n", __func__);
         goto bail;
     }
 
     ret = 0;
 
 bail:
     if (cipher)
         free(cipher);
     if (plain)
         free(plain);
     lws_genrsa_destroy(&pub_ctx);
     lws_genrsa_destroy(&priv_ctx);
     lws_genrsa_destroy_elements(el);
 
     return ret;
 }
 
static const uint8_t genrsa_fixed_plain[] = {
    0x63, 0x72, 0x6F, 0x73, 0x73, 0x20, 0x62, 0x61, 0x63, 0x6B, 0x65, 0x6E, 
    0x64, 0x20, 0x70, 0x72, 0x69, 0x76, 0x61, 0x74, 0x65, 0x20, 0x65, 0x6E, 
    0x63
};


static const uint8_t genrsa_fixed_e[] = {
    0x01, 0x00, 0x01
};
static const uint8_t genrsa_fixed_n[] = {
    0xBB, 0xC6, 0x88, 0x34, 0x96, 0xAC, 0xE5, 0x7C, 0xE1, 0x5B, 0xCD, 0x0B, 
    0x7D, 0x13, 0x81, 0xBB, 0x33, 0x03, 0xB3, 0x6A, 0x7D, 0x38, 0x5A, 0xF8, 
    0xEE, 0x51, 0x56, 0x1A, 0x81, 0xE4, 0x17, 0x2F, 0x17, 0xF8, 0xD9, 0x10, 
    0xA7, 0x7A, 0x12, 0x86, 0x02, 0xD9, 0x58, 0xF6, 0x40, 0x2B, 0xA7, 0x4A, 
    0x66, 0xDE, 0x04, 0x5E, 0x1E, 0xE0, 0x95, 0xCB, 0xE6, 0xC4, 0xCC, 0x12, 
    0xB6, 0x40, 0xDB, 0x4D, 0x62, 0xA6, 0x50, 0x7A, 0x74, 0xC3, 0x48, 0xC6, 
    0xD0, 0x5B, 0x0A, 0x5D, 0x99, 0xCC, 0x4C, 0x4C, 0xDB, 0x98, 0x9F, 0xBE, 
    0x93, 0xC8, 0x70, 0xAF, 0xF9, 0xA3, 0x16, 0x02, 0x3B, 0x13, 0x8F, 0x5B, 
    0xB0, 0x67, 0x4C, 0x08, 0x5B, 0x51, 0xA2, 0x99, 0x5C, 0xB9, 0x54, 0x03, 
    0xAC, 0x01, 0x5D, 0x2D, 0xE8, 0xFB, 0x27, 0x9F, 0x45, 0xDF, 0x38, 0x06, 
    0x77, 0xCD, 0x93, 0xC2, 0x1B, 0x01, 0x22, 0x90, 0x82, 0x44, 0x6B, 0x81, 
    0x97, 0x13, 0x74, 0x3E, 0x25, 0xF1, 0xE7, 0x7B, 0xEE, 0xC8, 0xF7, 0xA7, 
    0xA3, 0x10, 0x93, 0x3A, 0x97, 0x87, 0x58, 0x97, 0xBF, 0x8D, 0x4F, 0x25, 
    0x9E, 0xDB, 0x39, 0xD2, 0xD6, 0xAE, 0x69, 0x64, 0x1E, 0x49, 0x93, 0x2E, 
    0x59, 0x51, 0x79, 0xB7, 0xED, 0x18, 0xC0, 0x7F, 0x4B, 0xBB, 0xAD, 0xDA, 
    0xC4, 0xB8, 0x76, 0x14, 0x78, 0x58, 0x6E, 0xF1, 0x33, 0xD1, 0x3C, 0xCA, 
    0xDE, 0xFB, 0x30, 0x6C, 0xD0, 0xBB, 0x8A, 0x9A, 0xBD, 0x7D, 0x24, 0x70, 
    0xC3, 0x82, 0x1B, 0x68, 0x34, 0x6A, 0xEF, 0x11, 0x77, 0x27, 0x25, 0x0B, 
    0x0F, 0x2B, 0xBC, 0xE2, 0x6F, 0xB4, 0x74, 0x96, 0xF7, 0x67, 0xE3, 0x3C, 
    0x41, 0xE8, 0x1D, 0xEB, 0x35, 0x85, 0xEC, 0x7B, 0x29, 0x32, 0x91, 0x42, 
    0x93, 0xBE, 0x5B, 0x4A, 0x36, 0x71, 0x4F, 0x0E, 0x03, 0xD6, 0x75, 0x83, 
    0xBE, 0x3A, 0x38, 0x8B
};
static const uint8_t genrsa_fixed_d[] = {
    0x3C, 0x64, 0x12, 0x0B, 0x43, 0xC8, 0x70, 0x78, 0x34, 0xEC, 0x76, 0xEA, 
    0x32, 0x7C, 0x53, 0x15, 0x77, 0x47, 0x41, 0xED, 0x46, 0x3F, 0x99, 0x36, 
    0x85, 0x43, 0x20, 0x7B, 0x9E, 0xF9, 0xD2, 0x21, 0x01, 0xC7, 0x35, 0x5C, 
    0x9F, 0x58, 0x69, 0xDB, 0xB2, 0xCF, 0xDF, 0x46, 0x37, 0x86, 0x32, 0xA4, 
    0x01, 0xA8, 0x76, 0xE4, 0x24, 0x6F, 0x1B, 0x8E, 0x3B, 0xF6, 0x60, 0x21, 
    0xC6, 0x7E, 0xDE, 0x69, 0x29, 0x88, 0x8E, 0xCA, 0x8B, 0x82, 0x01, 0x06, 
    0x7C, 0x1D, 0x43, 0x9C, 0xAD, 0xE9, 0xA0, 0x42, 0x79, 0xBF, 0xC0, 0xE4, 
    0xA4, 0x97, 0xEA, 0xF2, 0x15, 0xCA, 0x07, 0x3A, 0x89, 0x70, 0x75, 0x83, 
    0x4A, 0x1D, 0x36, 0xBD, 0x5B, 0x4D, 0x4A, 0x8B, 0xA3, 0x60, 0x31, 0x6E, 
    0x8A, 0xE3, 0xD7, 0x69, 0x7C, 0x0C, 0x46, 0x86, 0x79, 0x8C, 0xDC, 0x72, 
    0x6C, 0x16, 0x70, 0x66, 0x95, 0x93, 0xCC, 0x5E, 0xFB, 0x6F, 0x27, 0x9A, 
    0x5B, 0x4F, 0xAD, 0xF5, 0xFF, 0xB2, 0x28, 0xB6, 0x6D, 0xAE, 0x03, 0x86, 
    0x8B, 0x0D, 0x35, 0x23, 0x1D, 0xFB, 0x4A, 0xFC, 0x24, 0x4E, 0x0D, 0xBB, 
    0x75, 0x94, 0x7A, 0x8C, 0x93, 0x10, 0x34, 0xEB, 0xAE, 0x0D, 0xDD, 0x4D, 
    0x7A, 0x41, 0xAE, 0x50, 0x4E, 0xA1, 0xA9, 0xC8, 0x61, 0xB6, 0xAF, 0xB4, 
    0xA7, 0x11, 0xF8, 0x28, 0xDC, 0x98, 0xED, 0x77, 0xA6, 0x3B, 0x0B, 0xE3, 
    0xD0, 0x31, 0x9F, 0x7C, 0x2D, 0x60, 0xE4, 0x9D, 0x9A, 0x1F, 0x88, 0xAD, 
    0x34, 0xAF, 0xB7, 0xA4, 0x26, 0x1A, 0x51, 0x10, 0x92, 0x80, 0x5C, 0x66, 
    0x2F, 0x5A, 0xB9, 0x1E, 0x90, 0x02, 0xCB, 0x01, 0xDE, 0x37, 0x34, 0xBE, 
    0x1D, 0x69, 0x39, 0x18, 0xFF, 0xAD, 0x8D, 0x98, 0xB1, 0xDA, 0x9D, 0xC6, 
    0xF6, 0x67, 0x8A, 0x3D, 0x37, 0x3E, 0xE5, 0x4E, 0xBF, 0x92, 0xC1, 0x13, 
    0xCE, 0xCB, 0xAE, 0x01
};
static const uint8_t genrsa_fixed_p[] = {
    0xE5, 0xCB, 0xA6, 0x73, 0x0E, 0xBE, 0x29, 0xA5, 0x59, 0x57, 0xD6, 0x1A, 
    0xE9, 0x14, 0x28, 0xD7, 0xB7, 0xB4, 0xF5, 0xC1, 0x68, 0x95, 0xFD, 0x78, 
    0x24, 0xDF, 0x28, 0xFC, 0x16, 0xCA, 0x09, 0xFE, 0x01, 0x3B, 0xB8, 0x6F, 
    0x72, 0x2A, 0xE5, 0x1B, 0xFA, 0x8E, 0xD6, 0x3E, 0x63, 0x8E, 0xBE, 0x21, 
    0xF7, 0x0C, 0xEA, 0x2B, 0xEA, 0x77, 0x42, 0x1D, 0x6F, 0x7B, 0x76, 0xA4, 
    0x26, 0x6A, 0x6E, 0xC5, 0xED, 0xBF, 0x62, 0x0B, 0x38, 0xFB, 0xEA, 0x0C, 
    0xC6, 0xF3, 0x73, 0x57, 0xB6, 0x97, 0xB8, 0xF1, 0xBC, 0x31, 0xC8, 0xC0, 
    0x56, 0xE6, 0xB6, 0x30, 0x96, 0x0D, 0xBB, 0xD0, 0xCD, 0xEF, 0xDA, 0xD4, 
    0xF1, 0xC7, 0xAF, 0xDD, 0x7B, 0x28, 0x7D, 0xA1, 0xEE, 0x76, 0x32, 0x6D, 
    0x89, 0xF3, 0x16, 0xC4, 0xB6, 0xC8, 0x83, 0x2B, 0x69, 0x8A, 0xE4, 0x25, 
    0xD2, 0x98, 0x7C, 0x2A, 0x88, 0xB4, 0xA2, 0x8B
};
static const uint8_t genrsa_fixed_q[] = {
    0xD1, 0x30, 0x34, 0x81, 0x50, 0xEB, 0x0E, 0x5E, 0xD8, 0x26, 0x82, 0x59, 
    0xC8, 0xE7, 0xE5, 0x63, 0xE8, 0x3A, 0x31, 0xAE, 0xCE, 0x13, 0x84, 0x18, 
    0xFC, 0xC5, 0xB2, 0xF4, 0x59, 0x15, 0x1A, 0x2C, 0xCF, 0x38, 0x4E, 0xA9, 
    0x90, 0x5D, 0xD2, 0x25, 0x71, 0xB6, 0x30, 0x3C, 0xA8, 0x68, 0x5A, 0xCB, 
    0xE9, 0x32, 0xEA, 0x88, 0x68, 0x80, 0xCB, 0x7A, 0x5C, 0xC9, 0x3E, 0x9E, 
    0x07, 0xF5, 0x3C, 0x41, 0x44, 0xCD, 0x74, 0x65, 0x81, 0x5C, 0xFE, 0x0D, 
    0x45, 0x57, 0xE0, 0xFA, 0xAB, 0x75, 0xB4, 0x13, 0xBD, 0x9F, 0xB9, 0x47, 
    0xD8, 0x8C, 0xF6, 0xC7, 0xEA, 0xE4, 0x89, 0x8E, 0xE9, 0xA8, 0xEB, 0xA2, 
    0xC7, 0xD8, 0x94, 0xCF, 0x96, 0xE2, 0x6D, 0xEB, 0xED, 0xC7, 0x32, 0x17, 
    0x7D, 0xB2, 0xA9, 0x02, 0x30, 0x14, 0x3E, 0x38, 0x3A, 0x3D, 0x6D, 0xAC, 
    0xA9, 0x71, 0x06, 0xC4, 0xC7, 0x51, 0x82, 0x01
};
static const uint8_t genrsa_expected_priv_enc[] = {
    0x8E, 0x5E, 0x14, 0x60, 0xC2, 0x58, 0xD7, 0xC9, 0x6C, 0x62, 0x7F, 0x41, 
    0x79, 0x64, 0xED, 0x4D, 0x97, 0xED, 0xCB, 0xEA, 0xA4, 0xCA, 0xB2, 0xA5, 
    0x98, 0xDD, 0x34, 0x45, 0x3B, 0xAB, 0xBF, 0x3C, 0x64, 0x32, 0x51, 0x00, 
    0xB2, 0xFF, 0x76, 0xBF, 0x80, 0x6D, 0xA3, 0x1F, 0xE8, 0xB2, 0x57, 0xD3, 
    0x23, 0x37, 0x5D, 0x0B, 0x29, 0x46, 0x9B, 0xDE, 0x84, 0x00, 0xCC, 0x92, 
    0xA0, 0xC7, 0xCE, 0x41, 0x7C, 0x18, 0xC9, 0x74, 0xF0, 0x5C, 0xF9, 0xD3, 
    0x2A, 0xFC, 0x84, 0x79, 0xBA, 0x5A, 0xBA, 0xB6, 0xE9, 0x43, 0xD9, 0xE3, 
    0x00, 0xD8, 0xE5, 0xD4, 0x84, 0x94, 0xF1, 0x29, 0x10, 0x80, 0xED, 0xEF, 
    0xE5, 0xD4, 0x57, 0xBC, 0x8C, 0x48, 0x0A, 0x09, 0x0A, 0xBD, 0x75, 0x27, 
    0x45, 0x0A, 0x5C, 0x3B, 0x67, 0x1E, 0x07, 0xC1, 0xC1, 0x44, 0x70, 0xD9, 
    0x6D, 0x4F, 0x73, 0x8E, 0x3F, 0x71, 0xA5, 0xDC, 0x00, 0x25, 0xB6, 0x56, 
    0xAB, 0x2D, 0x49, 0x98, 0x68, 0x60, 0x9D, 0x14, 0x3E, 0x25, 0x1F, 0xDD, 
    0xDF, 0x1C, 0x83, 0x28, 0x4C, 0xB2, 0x6A, 0xA9, 0xC0, 0x99, 0x3B, 0x89, 
    0x2F, 0x46, 0x77, 0xAE, 0xDD, 0x50, 0xCB, 0xED, 0x32, 0xD3, 0xC4, 0xB2, 
    0x0C, 0xF1, 0xA8, 0x12, 0x9B, 0x33, 0x6A, 0x0D, 0x11, 0x37, 0xDD, 0xFC, 
    0x17, 0x31, 0xA9, 0x56, 0x9D, 0x87, 0xD3, 0xB2, 0x24, 0x39, 0xE5, 0x26, 
    0xB9, 0x42, 0x22, 0x8E, 0xEC, 0xC3, 0xB5, 0x9F, 0xF3, 0x0E, 0x73, 0xE0, 
    0x68, 0x82, 0x84, 0x72, 0x59, 0x1A, 0xC9, 0x62, 0x5E, 0x7E, 0x8B, 0xF7, 
    0x36, 0x71, 0x90, 0xD9, 0x96, 0x40, 0x07, 0x01, 0x8A, 0xAF, 0x42, 0x83, 
    0x90, 0xD2, 0x6F, 0x24, 0x48, 0xEC, 0x34, 0xF8, 0x61, 0xBF, 0x0F, 0x8A, 
    0x60, 0x1D, 0x4A, 0x54, 0xB3, 0x7D, 0x21, 0x4B, 0x29, 0xFB, 0x3B, 0x4C, 
    0xB6, 0x8D, 0x99, 0x4A
};

static int
test_genrsa_fixed_vectors(struct lws_context *context)
{
	struct lws_genrsa_ctx priv_ctx, pub_ctx;
	struct lws_gencrypto_keyelem priv_el[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	struct lws_gencrypto_keyelem pub_el[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	uint8_t *cipher = NULL, *plain = NULL;
	size_t key_bytes = sizeof(genrsa_fixed_n);
	int n;
	int ret = 1;

	memset(&priv_ctx, 0, sizeof(priv_ctx));
	memset(&pub_ctx, 0, sizeof(pub_ctx));
	memset(priv_el, 0, sizeof(priv_el));
	memset(pub_el, 0, sizeof(pub_el));

	priv_el[LWS_GENCRYPTO_RSA_KEYEL_E].buf = (uint8_t *)(uintptr_t)genrsa_fixed_e;
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_E].len = (uint32_t)sizeof(genrsa_fixed_e);
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_N].buf = (uint8_t *)(uintptr_t)genrsa_fixed_n;
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_N].len = (uint32_t)sizeof(genrsa_fixed_n);
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_D].buf = (uint8_t *)(uintptr_t)genrsa_fixed_d;
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_D].len = (uint32_t)sizeof(genrsa_fixed_d);
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_P].buf = (uint8_t *)(uintptr_t)genrsa_fixed_p;
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_P].len = (uint32_t)sizeof(genrsa_fixed_p);
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_Q].buf = (uint8_t *)(uintptr_t)genrsa_fixed_q;
	priv_el[LWS_GENCRYPTO_RSA_KEYEL_Q].len = (uint32_t)sizeof(genrsa_fixed_q);
	test_genrsa_prepare_public_elements(pub_el, priv_el);

	if (lws_genrsa_create(&priv_ctx, priv_el, context, LGRSAM_PKCS1_1_5,
			      LWS_GENHASH_TYPE_UNKNOWN)) {
		lwsl_err("%s: lws_genrsa_create private ctx failed\n", __func__);
		goto bail;
	}

	if (lws_genrsa_create(&pub_ctx, pub_el, context, LGRSAM_PKCS1_1_5,
			      LWS_GENHASH_TYPE_UNKNOWN)) {
		lwsl_err("%s: lws_genrsa_create public ctx failed\n", __func__);
		goto bail;
	}

	cipher = malloc(key_bytes);
	plain = malloc(key_bytes);
	if (!cipher || !plain) {
		lwsl_err("%s: OOM allocating fixed test buffers\n", __func__);
		goto bail;
	}

	n = lws_genrsa_private_encrypt(&priv_ctx, genrsa_fixed_plain,
				       sizeof(genrsa_fixed_plain) - 1, cipher);
	if (n != (int)sizeof(genrsa_expected_priv_enc) ||
	    lws_timingsafe_bcmp(cipher, genrsa_expected_priv_enc,
				sizeof(genrsa_expected_priv_enc))) {
		lwsl_err("%s: fixed private_encrypt mismatch\n", __func__);
		goto bail;
	}

	n = lws_genrsa_public_decrypt(&pub_ctx, genrsa_expected_priv_enc,
				      sizeof(genrsa_expected_priv_enc), plain,
				      key_bytes);
	if (n != (int)(sizeof(genrsa_fixed_plain) - 1) ||
	    lws_timingsafe_bcmp(plain, genrsa_fixed_plain,
				sizeof(genrsa_fixed_plain) - 1)) {
		lwsl_err("%s: fixed public_decrypt mismatch\n", __func__);
		goto bail;
	}

	ret = 0;

bail:
	if (cipher)
		free(cipher);
	if (plain)
		free(plain);
	lws_genrsa_destroy(&pub_ctx);
	lws_genrsa_destroy(&priv_ctx);

	return ret;
}
#endif

#if defined(GENRSA_HAS_OAEP)
/*
 * OAEP-mode data encrypt / decrypt roundtrip: the data-op path BearSSL can
 * take part in, since BearSSL provides OAEP pieces.  Both ctxs are created
 * from the generated elements with the same OAEP hash, the way JOSE
 * creates them from a jwk
 */
static int
test_genrsa_oaep_roundtrips(struct lws_context *context)
{
	static const uint8_t plain[] = "public encrypt roundtrip";
	struct lws_genrsa_ctx gen, ctx, pub_ctx;
	struct lws_gencrypto_keyelem el[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	struct lws_gencrypto_keyelem pub_el[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	uint8_t cipher[512], back[512];
	int n, ret = 1;

	memset(&gen, 0, sizeof(gen));
	memset(&ctx, 0, sizeof(ctx));
	memset(&pub_ctx, 0, sizeof(pub_ctx));
	memset(el, 0, sizeof(el));
	memset(pub_el, 0, sizeof(pub_el));

	if (lws_genrsa_new_keypair(context, &gen, LGRSAM_PKCS1_OAEP_PSS, el,
				   2048)) {
		lwsl_err("%s: lws_genrsa_new_keypair failed\n", __func__);
		goto bail;
	}

	/* the generation ctx has done its job */
	lws_genrsa_destroy(&gen);

	test_genrsa_prepare_public_elements(pub_el, el);

	if (lws_genrsa_create(&pub_ctx, pub_el, context,
			      LGRSAM_PKCS1_OAEP_PSS,
			      LWS_GENHASH_TYPE_SHA256) ||
	    lws_genrsa_create(&ctx, el, context, LGRSAM_PKCS1_OAEP_PSS,
			      LWS_GENHASH_TYPE_SHA256)) {
		lwsl_err("%s: lws_genrsa_create failed\n", __func__);
		goto bail;
	}

	n = lws_genrsa_public_encrypt(&pub_ctx, plain, sizeof(plain) - 1,
				      cipher);
	if (n < 0) {
		lwsl_err("%s: lws_genrsa_public_encrypt failed\n", __func__);
		goto bail;
	}

	n = lws_genrsa_private_decrypt(&ctx, cipher, (size_t)n, back,
				       sizeof(back));
	if (n < 0) {
		lwsl_err("%s: lws_genrsa_private_decrypt failed\n", __func__);
		goto bail;
	}

	if (n != (int)(sizeof(plain) - 1) ||
	    lws_timingsafe_bcmp(back, plain, sizeof(plain) - 1)) {
		lwsl_err("%s: OAEP roundtrip mismatch\n", __func__);
		goto bail;
	}

	ret = 0;

bail:
	lws_genrsa_destroy(&pub_ctx);
	lws_genrsa_destroy(&ctx);
	lws_genrsa_destroy_elements(el);

	return ret;
}
#endif

#if defined(GENRSA_HAS_KEYGEN_SIGNVERIFY)

/* hash with the generic hash api, for the sign / verify probes */

static int
test_genrsa_hash32(const void *in, size_t in_len, uint8_t *hash32)
{
	struct lws_genhash_ctx gh;

	if (lws_genhash_init(&gh, LWS_GENHASH_TYPE_SHA256) ||
	    lws_genhash_update(&gh, in, in_len) ||
	    lws_genhash_destroy(&gh, hash32))
		return 1;

	return 0;
}

/*
 * F-045 fence: ctx liveness rules.  create() and new_keypair() over a ctx
 * that still holds a live key incarnation must fail cleanly; after
 * destroy(), the same ctx can be recreated and operates with the new key
 *
 * The probes use the sign / verify apis, which every backend this fence
 * runs on provides
 */
static int
test_genrsa_recreate(struct lws_context *context)
{
	static const uint8_t plain_a[] = "recreate roundtrip A";
	static const uint8_t plain_b[] = "recreate roundtrip B";
	struct lws_genrsa_ctx ctx, ctx2, pub1, pub2;
	struct lws_gencrypto_keyelem el[2][LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	struct lws_gencrypto_keyelem pub_el[2][LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	struct lws_gencrypto_keyelem gen[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	uint8_t hash[32], sig[512];
	int n, ret = 1;

	memset(&ctx, 0, sizeof(ctx));
	memset(&ctx2, 0, sizeof(ctx2));
	memset(&pub1, 0, sizeof(pub1));
	memset(&pub2, 0, sizeof(pub2));
	memset(el, 0, sizeof(el));
	memset(pub_el, 0, sizeof(pub_el));
	memset(gen, 0, sizeof(gen));

	/* two independent keypairs, in two live ctxs */

	if (lws_genrsa_new_keypair(context, &ctx, LGRSAM_PKCS1_1_5, el[0],
				   2048)) {
		lwsl_err("%s: new_keypair 0 failed\n", __func__);
		goto bail;
	}

	if (lws_genrsa_new_keypair(context, &ctx2, LGRSAM_PKCS1_1_5, el[1],
				   2048)) {
		lwsl_err("%s: new_keypair 1 failed\n", __func__);
		goto bail;
	}

	test_genrsa_prepare_public_elements(pub_el[0], el[0]);
	test_genrsa_prepare_public_elements(pub_el[1], el[1]);

	if (lws_genrsa_create(&pub1, pub_el[0], context, LGRSAM_PKCS1_1_5,
			      LWS_GENHASH_TYPE_UNKNOWN) ||
	    lws_genrsa_create(&pub2, pub_el[1], context, LGRSAM_PKCS1_1_5,
			      LWS_GENHASH_TYPE_UNKNOWN)) {
		lwsl_err("%s: pub ctx create failed\n", __func__);
		goto bail;
	}

	/* sanity: ctx currently operates with key 0 */

	if (test_genrsa_hash32(plain_a, sizeof(plain_a) - 1, hash)) {
		lwsl_err("%s: hash failed\n", __func__);
		goto bail;
	}

	n = lws_genrsa_hash_sign(&ctx, hash, LWS_GENHASH_TYPE_SHA256,
				 sig, sizeof(sig));
	if (n < 0) {
		lwsl_err("%s: sign sanity failed\n", __func__);
		goto bail;
	}

	if (lws_genrsa_hash_sig_verify(&pub1, hash,
				       LWS_GENHASH_TYPE_SHA256,
				       sig, (size_t)n)) {
		lwsl_err("%s: sanity sign/verify mismatch\n", __func__);
		goto bail;
	}

	/*
	 * create() over the live ctx must fail; after destroy(), the same ctx
	 * can be recreated with key 1's elements
	 */

	if (!lws_genrsa_create(&ctx, el[1], context, LGRSAM_PKCS1_1_5,
			       LWS_GENHASH_TYPE_UNKNOWN)) {
		lwsl_err("%s: create over live ctx accepted\n", __func__);
		goto bail;
	}

	lws_genrsa_destroy(&ctx);

	if (lws_genrsa_create(&ctx, el[1], context, LGRSAM_PKCS1_1_5,
			      LWS_GENHASH_TYPE_UNKNOWN)) {
		lwsl_err("%s: recreate after destroy failed\n", __func__);
		goto bail;
	}

	if (test_genrsa_hash32(plain_b, sizeof(plain_b) - 1, hash)) {
		lwsl_err("%s: hash failed\n", __func__);
		goto bail;
	}

	n = lws_genrsa_hash_sign(&ctx, hash, LWS_GENHASH_TYPE_SHA256,
				 sig, sizeof(sig));
	if (n < 0) {
		lwsl_err("%s: sign after recreate failed\n", __func__);
		goto bail;
	}

	if (lws_genrsa_hash_sig_verify(&pub2, hash,
				       LWS_GENHASH_TYPE_SHA256,
				       sig, (size_t)n)) {
		lwsl_err("%s: recreated ctx not operating with key 1\n",
			 __func__);
		goto bail;
	}

	/* ...and it must no longer be operating with key 0 */

	if (!lws_genrsa_hash_sig_verify(&pub1, hash,
					LWS_GENHASH_TYPE_SHA256,
					sig, (size_t)n)) {
		lwsl_err("%s: recreated ctx still operating with key 0\n",
			 __func__);
		goto bail;
	}

	/* destroy + recreate again restores key 0 */

	lws_genrsa_destroy(&ctx);

	if (lws_genrsa_create(&ctx, el[0], context, LGRSAM_PKCS1_1_5,
			      LWS_GENHASH_TYPE_UNKNOWN)) {
		lwsl_err("%s: recreate with key 0 failed\n", __func__);
		goto bail;
	}

	if (test_genrsa_hash32(plain_a, sizeof(plain_a) - 1, hash)) {
		lwsl_err("%s: hash failed\n", __func__);
		goto bail;
	}

	n = lws_genrsa_hash_sign(&ctx, hash, LWS_GENHASH_TYPE_SHA256,
				 sig, sizeof(sig));
	if (n < 0) {
		lwsl_err("%s: sign after second recreate failed\n",
			 __func__);
		goto bail;
	}

	if (lws_genrsa_hash_sig_verify(&pub1, hash,
				       LWS_GENHASH_TYPE_SHA256,
				       sig, (size_t)n)) {
		lwsl_err("%s: second recreate sign/verify mismatch\n",
			 __func__);
		goto bail;
	}

	/*
	 * new_keypair() over the live keyed ctx must fail too; after
	 * destroy() it generates a fresh key into the same ctx
	 */

	if (!lws_genrsa_new_keypair(context, &ctx, LGRSAM_PKCS1_1_5, gen,
				    2048)) {
		lwsl_err("%s: new_keypair over live ctx accepted\n", __func__);
		goto bail;
	}

	lws_genrsa_destroy(&ctx);

	if (lws_genrsa_new_keypair(context, &ctx, LGRSAM_PKCS1_1_5, gen,
				   2048)) {
		lwsl_err("%s: new_keypair after destroy failed\n", __func__);
		goto bail;
	}

	ret = 0;

bail:
	lws_genrsa_destroy(&pub2);
	lws_genrsa_destroy(&pub1);
	lws_genrsa_destroy(&ctx2);
	lws_genrsa_destroy(&ctx);
	lws_genrsa_destroy_elements(el[0]);
	lws_genrsa_destroy_elements(el[1]);
	lws_genrsa_destroy_elements(gen);

	return ret;
}
#endif


/*
 * RSA-PSS, ie, the JWS PS256 / PS384 / PS512 signature algs.
 *
 * PSS salts its encoding randomly, so a signature we produce cannot be
 * compared against a fixed vector.  Each alg is checked three ways instead:
 *
 *  - a sign + verify round trip, which drives our own PSS signing path
 *
 *  - verification of a fixed signature made outside lws over the same key
 *    and message, so a backend that agrees with itself while doing the wrong
 *    thing is still caught... signing and verifying PKCS#1 v1.5 in place of
 *    PSS, or PSS with the wrong MGF1 hash or salt length, all fail here
 *
 *  - a PKCS#1 v1.5 signature over the same hash must be REJECTED by the PSS
 *    verify, a direct fence on that confusion
 *
 * The vectors are RFC 8017 RSASSA-PSS over the 2048-bit key below, MGF1 on
 * the same hash as the message digest and a salt of the digest length, which
 * is what RFC 7518 requires for PS256 / PS384 / PS512.
 */

static const char *genrsa_pss_msg = "lws api-test-gencrypto RSA-PSS test vector";

static const uint8_t genrsa_pss_n[] = {
	0xa9, 0x4c, 0xcd, 0xda, 0xf8, 0x22, 0xdd, 0x22, 0xdd, 0x66, 0x0f, 0xcc,
	0x51, 0x9c, 0x7c, 0x7a, 0x6a, 0x9f, 0x6f, 0x58, 0x90, 0xeb, 0x05, 0x79,
	0x3b, 0x96, 0x2d, 0xc7, 0x18, 0x19, 0x88, 0x52, 0xb0, 0x0c, 0x17, 0x71,
	0x21, 0x3a, 0xc1, 0x72, 0xf8, 0x3b, 0x43, 0xfa, 0x12, 0xe2, 0x80, 0xe5,
	0xf2, 0xca, 0xee, 0xa3, 0x5a, 0x68, 0x07, 0xa3, 0x63, 0xe0, 0x3c, 0x34,
	0x0a, 0x3f, 0xdf, 0x45, 0x57, 0x93, 0x4d, 0xf0, 0xc1, 0x63, 0x2e, 0xf3,
	0xa3, 0xcb, 0xb6, 0xaa, 0xcd, 0xb5, 0xd0, 0x8c, 0xce, 0x83, 0xb5, 0x37,
	0xda, 0x85, 0xcf, 0x1d, 0x34, 0xcb, 0x31, 0x7d, 0x24, 0x51, 0x94, 0x37,
	0xbb, 0xf4, 0x9c, 0x5a, 0xab, 0xd5, 0x8a, 0xb4, 0xf5, 0x61, 0xe9, 0xfd,
	0x89, 0x2b, 0x85, 0x03, 0xcf, 0x44, 0x46, 0xd1, 0xd4, 0x78, 0xaf, 0x64,
	0xe2, 0x9e, 0x2e, 0x2c, 0xb1, 0x98, 0xa7, 0x8b, 0x54, 0xb7, 0xce, 0x51,
	0xab, 0xdb, 0x5f, 0xbd, 0x32, 0xc2, 0x3f, 0x32, 0x6e, 0xbe, 0x91, 0x3d,
	0x73, 0x66, 0x17, 0x08, 0x28, 0x0c, 0xac, 0xd7, 0x6a, 0x73, 0x49, 0xa6,
	0x11, 0xdb, 0x83, 0x9f, 0x60, 0x32, 0xa3, 0x6e, 0xe9, 0xff, 0x8d, 0x7b,
	0x11, 0xcf, 0xcb, 0x6c, 0x3e, 0x43, 0xa7, 0xad, 0x93, 0xb9, 0x7e, 0x10,
	0x21, 0x28, 0xaa, 0x89, 0xe8, 0x76, 0x1e, 0xf1, 0x6e, 0x3a, 0xfc, 0xae,
	0xee, 0xae, 0x39, 0x72, 0x10, 0x59, 0x52, 0x5b, 0xb2, 0x04, 0xe5, 0xf5,
	0x81, 0x6a, 0xe4, 0x32, 0x90, 0x3c, 0x7d, 0xd2, 0xbb, 0xea, 0x74, 0x24,
	0x60, 0xf9, 0xb7, 0x2d, 0x08, 0xd6, 0x8a, 0x53, 0xfe, 0x6a, 0xcc, 0x27,
	0xde, 0x70, 0x4f, 0xb2, 0xfe, 0x93, 0xcf, 0xb9, 0x5f, 0x04, 0x76, 0xbe,
	0x01, 0x36, 0x8d, 0x16, 0x8d, 0x99, 0xa7, 0x78, 0x91, 0xec, 0xdb, 0xa1,
	0x91, 0x40, 0xfa, 0xdd,
};

static const uint8_t genrsa_pss_e[] = {
	0x01, 0x00, 0x01,
};

static const uint8_t genrsa_pss_d[] = {
	0x05, 0x8b, 0xf5, 0xcd, 0xf5, 0x45, 0x95, 0xcf, 0x7f, 0xc7, 0xc9, 0x6a,
	0x62, 0x72, 0xc9, 0x39, 0xec, 0xdc, 0x06, 0xb6, 0xb4, 0xf4, 0xc6, 0x41,
	0x4d, 0x11, 0xa4, 0x09, 0x50, 0x56, 0xfc, 0x7a, 0x3d, 0x0e, 0x00, 0x5c,
	0x9d, 0x55, 0x42, 0xa3, 0x9a, 0x27, 0x68, 0x42, 0xe8, 0x08, 0x7c, 0xbc,
	0x4b, 0xed, 0x43, 0x23, 0xf3, 0x4b, 0xd2, 0x3d, 0x93, 0xac, 0x49, 0x3c,
	0xa9, 0x3d, 0xf8, 0xcf, 0x84, 0x49, 0x82, 0xb5, 0xb4, 0x6d, 0xa3, 0xf5,
	0xa9, 0x34, 0x52, 0x3f, 0xf1, 0x57, 0xc2, 0x1a, 0x98, 0x3a, 0x2f, 0x74,
	0x97, 0x82, 0x67, 0xcb, 0xe7, 0x55, 0x65, 0x97, 0x2f, 0x2f, 0xef, 0x0b,
	0xb9, 0x15, 0x90, 0x0e, 0x81, 0x1a, 0x66, 0x1e, 0x27, 0x50, 0xa0, 0x6d,
	0x1a, 0x92, 0x8e, 0xf1, 0x40, 0xd8, 0x00, 0xa6, 0xa7, 0x9a, 0x96, 0xa0,
	0x81, 0xb3, 0x8e, 0x04, 0x0f, 0xd8, 0xd6, 0x5b, 0x08, 0x1c, 0x8c, 0x68,
	0xa0, 0xef, 0xf3, 0x9c, 0x1f, 0x54, 0xb5, 0xf4, 0xf8, 0x3a, 0xfc, 0xd0,
	0x73, 0x7f, 0x26, 0x4c, 0x41, 0xfc, 0xb3, 0xe6, 0x2b, 0x05, 0x39, 0x2c,
	0xff, 0xea, 0x9f, 0x67, 0xd0, 0xfd, 0x44, 0x96, 0x3f, 0x2b, 0xea, 0x8e,
	0x7d, 0x1d, 0xb3, 0x29, 0x8c, 0x5b, 0x70, 0x82, 0xce, 0x67, 0xf4, 0x10,
	0xd7, 0xd3, 0x2e, 0xfc, 0xba, 0xc1, 0xd9, 0x0a, 0xf9, 0x91, 0x81, 0x42,
	0xe6, 0x4f, 0x9a, 0x07, 0x09, 0x07, 0x33, 0x32, 0x51, 0x09, 0x92, 0xef,
	0x0c, 0x94, 0xaa, 0xf8, 0x29, 0xb6, 0xff, 0xa2, 0x67, 0x0d, 0x44, 0x4b,
	0x52, 0xed, 0x76, 0xa5, 0x7d, 0xbe, 0x14, 0xe0, 0xbf, 0x8b, 0x60, 0xe8,
	0x5d, 0xb4, 0xb9, 0x90, 0xb6, 0xd6, 0xba, 0x2f, 0x9d, 0x85, 0x6d, 0xe0,
	0x0e, 0x0f, 0x92, 0x4c, 0x92, 0x03, 0x8e, 0x28, 0x65, 0x8b, 0x48, 0x8f,
	0xc8, 0x6f, 0x68, 0xff,
};

static const uint8_t genrsa_pss_p[] = {
	0xd8, 0xda, 0x4b, 0x64, 0xe4, 0x38, 0xef, 0x66, 0x54, 0xb7, 0xe8, 0x4a,
	0xb9, 0x70, 0x21, 0x24, 0x6c, 0x23, 0xba, 0xc6, 0x8e, 0x24, 0x47, 0xd9,
	0x2a, 0x71, 0xad, 0x97, 0x5b, 0x2c, 0xec, 0x3a, 0x09, 0xc6, 0x15, 0xf7,
	0x81, 0xcf, 0xfe, 0x6c, 0x25, 0xf9, 0x44, 0xb6, 0x61, 0xb7, 0xa8, 0x01,
	0xe7, 0xbe, 0x8b, 0x48, 0x4a, 0x68, 0xc5, 0x56, 0xd2, 0x8a, 0xef, 0xba,
	0x20, 0xf2, 0xbb, 0xe8, 0xaf, 0x1a, 0x79, 0x5d, 0x7d, 0xd9, 0x01, 0x58,
	0x77, 0x30, 0x61, 0x32, 0xfa, 0x9e, 0xeb, 0x16, 0xf9, 0x02, 0xd3, 0x45,
	0x53, 0xfe, 0x9f, 0x4b, 0x36, 0xdd, 0xf4, 0x62, 0xc3, 0x9c, 0xe5, 0xb6,
	0xa5, 0xa8, 0x51, 0x7f, 0xbb, 0xc6, 0x32, 0x99, 0x0e, 0x4d, 0xdf, 0x69,
	0x23, 0xc5, 0x1c, 0x51, 0x01, 0x6f, 0x73, 0xd4, 0x65, 0x02, 0x28, 0xeb,
	0xc6, 0xa1, 0xaa, 0xe8, 0x6d, 0x20, 0x02, 0x7f,
};

static const uint8_t genrsa_pss_q[] = {
	0xc7, 0xdc, 0xe4, 0x9c, 0x38, 0x7e, 0x3a, 0x5c, 0x47, 0x84, 0x36, 0xf3,
	0x5e, 0xc0, 0xb6, 0x26, 0x9f, 0x75, 0xcf, 0xb7, 0xfa, 0xb9, 0x88, 0x33,
	0x4b, 0xb4, 0x16, 0xb7, 0x21, 0x65, 0x35, 0x66, 0x0b, 0xad, 0xb8, 0x8b,
	0x9a, 0xe0, 0xa4, 0xa6, 0x51, 0x9d, 0x8a, 0xd5, 0x79, 0x64, 0x2c, 0x3b,
	0x6d, 0xf8, 0xa0, 0x75, 0x77, 0x53, 0x3e, 0x0d, 0xc7, 0x38, 0x3f, 0xab,
	0xac, 0x86, 0xed, 0x53, 0xb3, 0xd2, 0xbd, 0xc2, 0x4c, 0x91, 0x05, 0x6b,
	0xb9, 0x61, 0xf7, 0x01, 0x19, 0x5c, 0x40, 0x62, 0xc9, 0x75, 0xcb, 0x5f,
	0x15, 0x7e, 0xd1, 0x1a, 0x09, 0x86, 0x75, 0xcb, 0x79, 0xd5, 0xd5, 0xf4,
	0x82, 0xc5, 0xa4, 0xf4, 0x02, 0x80, 0x8c, 0xf6, 0x99, 0x67, 0x4c, 0xa7,
	0x4d, 0x4e, 0x17, 0x10, 0x81, 0xae, 0x23, 0x28, 0x3f, 0xbf, 0x1d, 0xe7,
	0x06, 0x59, 0x62, 0xb6, 0x0a, 0xa6, 0x9c, 0xa3,
};

static const uint8_t genrsa_pss_dp[] = {
	0xa4, 0xd2, 0xff, 0x5d, 0x57, 0x4e, 0xa3, 0x40, 0x3f, 0x82, 0x6d, 0x90,
	0x66, 0x74, 0x80, 0xec, 0x63, 0x39, 0xa1, 0x1c, 0x8c, 0x2b, 0xad, 0x64,
	0xb6, 0x2b, 0x23, 0x8b, 0x98, 0xa4, 0x83, 0x84, 0xf5, 0xaa, 0xd7, 0x45,
	0x82, 0x28, 0xaa, 0xb4, 0x5f, 0x04, 0xa1, 0x22, 0x93, 0x11, 0x7a, 0x24,
	0xc0, 0x95, 0x86, 0xde, 0x52, 0x98, 0x61, 0xee, 0x45, 0x27, 0x8f, 0x61,
	0x04, 0xec, 0x1a, 0xc1, 0x98, 0x5e, 0x62, 0x03, 0x1a, 0xc5, 0x97, 0x8d,
	0x3b, 0x42, 0xcd, 0x8e, 0x67, 0x09, 0xe5, 0x9c, 0x57, 0x76, 0xbb, 0x48,
	0xc5, 0xb8, 0x12, 0x31, 0xa4, 0x29, 0x7e, 0x38, 0x97, 0x80, 0x28, 0xe5,
	0xf3, 0xf2, 0x04, 0xc8, 0x36, 0xdc, 0x45, 0xd7, 0x2a, 0x15, 0x2c, 0x8b,
	0x88, 0xc1, 0xa8, 0x6d, 0x35, 0xcf, 0x15, 0xd6, 0x49, 0x54, 0x23, 0xf0,
	0x59, 0xd0, 0xc5, 0xcb, 0xd6, 0x2d, 0xef, 0x57,
};

static const uint8_t genrsa_pss_dq[] = {
	0x25, 0xb3, 0xd2, 0xe0, 0x71, 0x7b, 0xc6, 0x70, 0xa0, 0x01, 0x1e, 0x08,
	0x9d, 0x08, 0x47, 0x94, 0x53, 0xa2, 0x7a, 0xd3, 0xdf, 0x15, 0x5e, 0xcf,
	0x26, 0x69, 0xcb, 0x9b, 0x32, 0x4e, 0x90, 0x5b, 0x36, 0xba, 0xc7, 0xc4,
	0x76, 0x2c, 0x08, 0x83, 0x63, 0x84, 0x0f, 0xab, 0xa3, 0xa1, 0xb5, 0x02,
	0x65, 0x05, 0x70, 0xe7, 0x97, 0xe1, 0xf9, 0x23, 0xca, 0x40, 0x1f, 0x2a,
	0xb8, 0x7a, 0x1f, 0x8d, 0x19, 0xb0, 0x18, 0xa1, 0xed, 0xa5, 0xb1, 0xdb,
	0x17, 0x76, 0x96, 0x8c, 0xfb, 0x86, 0xbe, 0x92, 0xa4, 0x24, 0x77, 0x7f,
	0xf1, 0x63, 0x21, 0xf9, 0x02, 0x70, 0xfe, 0x09, 0xab, 0x6b, 0x1e, 0x58,
	0x68, 0xce, 0xf6, 0x06, 0x1d, 0xee, 0xb8, 0x28, 0xd0, 0xd9, 0x7e, 0xc9,
	0x54, 0xb8, 0xf5, 0x7a, 0xe4, 0xab, 0xbf, 0xf0, 0x18, 0xce, 0x69, 0xca,
	0xaa, 0x14, 0xf4, 0x9d, 0x18, 0xb7, 0x43, 0x77,
};

static const uint8_t genrsa_pss_qi[] = {
	0x62, 0xd0, 0xa2, 0x15, 0x76, 0x72, 0x2d, 0x02, 0x69, 0x39, 0x04, 0xdf,
	0xeb, 0x26, 0x57, 0x45, 0xc1, 0xdc, 0x7e, 0x85, 0x29, 0xf9, 0xa9, 0x6e,
	0x77, 0x79, 0x17, 0xc0, 0xb1, 0x74, 0xad, 0x3a, 0x28, 0xba, 0x4e, 0x98,
	0x0b, 0x0a, 0xad, 0x72, 0x12, 0xa3, 0x5b, 0x50, 0xbe, 0x77, 0x50, 0x44,
	0xe5, 0xf2, 0xeb, 0x5b, 0x97, 0x41, 0xaf, 0x0d, 0x4d, 0x7c, 0x11, 0x0b,
	0x14, 0xbb, 0x9d, 0xde, 0xc3, 0x75, 0x8d, 0x39, 0xe4, 0xef, 0xce, 0x9a,
	0xb4, 0xa9, 0x65, 0x3e, 0x7e, 0xb9, 0x5c, 0x2c, 0x6c, 0xd1, 0x45, 0x2f,
	0xd1, 0x80, 0x72, 0x5e, 0x47, 0x39, 0xd7, 0x6f, 0x04, 0x7b, 0xf7, 0x18,
	0x0d, 0xef, 0xb7, 0xcd, 0xb7, 0x21, 0xb5, 0xa5, 0x67, 0xf1, 0xb8, 0x80,
	0x36, 0x8a, 0xb1, 0x38, 0x4d, 0xd8, 0xb4, 0xef, 0x59, 0x05, 0x8a, 0x88,
	0x81, 0x90, 0xf7, 0x23, 0x2c, 0x04, 0x76, 0xd1,
};

static const uint8_t genrsa_pss_sig_sha256[] = {
	0x16, 0xdf, 0x80, 0xcf, 0x42, 0xe4, 0x61, 0x43, 0xdb, 0x12, 0xd7, 0x09,
	0x74, 0xcc, 0x6b, 0x03, 0x16, 0xef, 0x56, 0x87, 0x8c, 0xb1, 0xfd, 0x54,
	0xa2, 0x59, 0x9f, 0x02, 0x02, 0x2a, 0x8d, 0x1a, 0x05, 0x77, 0xa1, 0x2a,
	0xd7, 0x12, 0x81, 0x16, 0x6c, 0x9c, 0xb1, 0xad, 0x55, 0xb7, 0x5b, 0x7e,
	0x72, 0x77, 0xac, 0x0c, 0x5f, 0x33, 0x4e, 0x15, 0x49, 0x32, 0x97, 0x3a,
	0x24, 0x72, 0xfe, 0x5e, 0x02, 0x86, 0x3b, 0x03, 0x3e, 0x0c, 0x39, 0x95,
	0xbc, 0x81, 0x30, 0x2c, 0x11, 0x93, 0x53, 0xdd, 0x9c, 0x5d, 0xc7, 0xde,
	0x77, 0x97, 0x11, 0x87, 0xf3, 0x20, 0x4b, 0xf7, 0x2a, 0x13, 0xc9, 0x6d,
	0x17, 0x28, 0xf8, 0xae, 0x27, 0x84, 0xd7, 0x07, 0x20, 0x59, 0xdf, 0x77,
	0x12, 0x46, 0xbc, 0xe2, 0x40, 0x1f, 0xd5, 0x8e, 0x0e, 0xc7, 0x26, 0xbe,
	0xbc, 0x98, 0xa9, 0x7b, 0xc1, 0x0f, 0xdd, 0xcd, 0x92, 0x14, 0xd2, 0xd1,
	0x85, 0xe8, 0xbc, 0x13, 0x6a, 0xed, 0x5e, 0xa3, 0x40, 0x7e, 0xd6, 0x5a,
	0xd7, 0xe0, 0xce, 0x34, 0xb4, 0xb9, 0xeb, 0x58, 0xbc, 0x3c, 0x5f, 0xc5,
	0xf1, 0xf8, 0xa1, 0x7c, 0xda, 0x6f, 0x19, 0xbd, 0xc1, 0xcb, 0x7a, 0xc5,
	0x2e, 0x4d, 0xa3, 0xb5, 0xf6, 0xf2, 0x83, 0xe0, 0xbf, 0x1d, 0x6c, 0x8c,
	0x33, 0x51, 0xb0, 0x13, 0x07, 0x14, 0xe7, 0x66, 0x82, 0x47, 0x72, 0xa0,
	0xe5, 0x1a, 0x3b, 0x78, 0x1b, 0xb0, 0xdd, 0x82, 0x6f, 0xeb, 0x2f, 0x62,
	0xd4, 0xf1, 0x85, 0x2c, 0x51, 0x62, 0x7a, 0x1e, 0x41, 0xd5, 0x25, 0x61,
	0x43, 0x8c, 0x5c, 0xdf, 0xbe, 0xc9, 0xa3, 0xca, 0x00, 0x15, 0x2c, 0xfe,
	0xb0, 0x05, 0xff, 0x8b, 0x08, 0x03, 0xb5, 0x38, 0x81, 0xc4, 0x67, 0xc1,
	0xe0, 0xc8, 0xf2, 0xf3, 0xc8, 0x4f, 0x3b, 0x23, 0x3f, 0x68, 0x4b, 0x7d,
	0xb6, 0xe0, 0x85, 0x5e,
};

static const uint8_t genrsa_pss_sig_sha384[] = {
	0x2a, 0x9f, 0x7a, 0xa9, 0xb9, 0xc9, 0x16, 0xab, 0xd5, 0x45, 0x37, 0x23,
	0x61, 0x70, 0x8f, 0xa9, 0x59, 0x91, 0x23, 0x90, 0xcc, 0x79, 0x92, 0xc2,
	0x3e, 0x2e, 0x64, 0x7b, 0xca, 0x3a, 0x22, 0x3a, 0x66, 0x70, 0x26, 0x14,
	0xca, 0x29, 0xb6, 0x0c, 0x2a, 0xe4, 0x97, 0xd3, 0xa6, 0x14, 0x08, 0xe8,
	0xff, 0x44, 0xc8, 0x4f, 0xbe, 0x37, 0x62, 0x8c, 0xdc, 0xdb, 0x38, 0x6d,
	0x7f, 0x7d, 0xd3, 0x47, 0xcf, 0x78, 0x72, 0x98, 0xad, 0x04, 0x5a, 0x08,
	0x83, 0x76, 0xc0, 0x36, 0xc6, 0x0b, 0x0e, 0x03, 0xa7, 0xec, 0x56, 0x90,
	0x0c, 0xaf, 0x14, 0x4e, 0x29, 0xab, 0x44, 0xad, 0x47, 0x15, 0x18, 0x63,
	0x85, 0x60, 0x72, 0x1d, 0x9a, 0x86, 0xcc, 0xc0, 0x84, 0xc0, 0x81, 0xdc,
	0xf6, 0x88, 0xb5, 0x7e, 0x8e, 0xd0, 0xb5, 0xbd, 0x74, 0xea, 0xbd, 0x86,
	0xce, 0xbf, 0x54, 0x5e, 0x33, 0xd1, 0x73, 0x7d, 0x94, 0x88, 0xdc, 0x6c,
	0xa7, 0xb2, 0xfe, 0x07, 0x22, 0x8a, 0x3d, 0xcb, 0x15, 0xb5, 0x92, 0xea,
	0xf5, 0xe8, 0xcf, 0x13, 0x8d, 0x04, 0xae, 0xb4, 0x63, 0x79, 0x64, 0xda,
	0xfe, 0x26, 0x9f, 0x41, 0x22, 0x48, 0x6e, 0x05, 0xd8, 0x15, 0xe5, 0x33,
	0x5b, 0x27, 0x56, 0x59, 0x5d, 0x53, 0xba, 0x69, 0xa9, 0x63, 0x40, 0x8c,
	0xef, 0x36, 0x45, 0xf5, 0xfe, 0xee, 0x45, 0x0d, 0x98, 0xd1, 0xab, 0x14,
	0xbf, 0xe7, 0xb5, 0x9e, 0x42, 0x9e, 0x64, 0x05, 0x03, 0xae, 0x43, 0xce,
	0xba, 0x72, 0x6a, 0x56, 0xb7, 0xc3, 0x58, 0xd0, 0x88, 0x5a, 0x6a, 0x5d,
	0x48, 0x67, 0x19, 0x2e, 0xb7, 0x09, 0xdb, 0xcb, 0x1c, 0xc7, 0x34, 0xbb,
	0x18, 0x65, 0x7d, 0xe6, 0x37, 0x92, 0x96, 0xe8, 0xea, 0x81, 0xd1, 0xd4,
	0x43, 0xf0, 0x72, 0x83, 0x56, 0x81, 0x57, 0x5f, 0x92, 0xb0, 0x2d, 0xe1,
	0x22, 0x61, 0x3d, 0x30,
};

static const uint8_t genrsa_pss_sig_sha512[] = {
	0x12, 0x61, 0x74, 0xa2, 0xf1, 0x9f, 0x98, 0x6b, 0xcf, 0xad, 0x62, 0x57,
	0xfd, 0xe8, 0xa7, 0xc8, 0xd9, 0xd0, 0xa4, 0xfe, 0x84, 0x45, 0xd3, 0x32,
	0x95, 0x2b, 0xfe, 0x8d, 0x99, 0x3c, 0x85, 0xb0, 0xac, 0x5c, 0x34, 0xd3,
	0x0b, 0x02, 0xda, 0xe1, 0xcd, 0x05, 0x94, 0x27, 0xd0, 0xb2, 0x2b, 0xa4,
	0xfb, 0xc2, 0x8c, 0x46, 0x93, 0x15, 0xe9, 0x5b, 0x9f, 0x3a, 0x98, 0x8c,
	0x05, 0xa0, 0x5f, 0x29, 0x53, 0x2a, 0xc3, 0x98, 0x2e, 0x31, 0xbb, 0xf6,
	0x29, 0xb6, 0x0a, 0x21, 0x8a, 0x7f, 0xf7, 0x93, 0x9c, 0xcd, 0x29, 0x18,
	0xdc, 0xd0, 0xd8, 0x64, 0x8c, 0xbe, 0xd2, 0xf9, 0xea, 0xc9, 0x45, 0x82,
	0x7f, 0x92, 0xe3, 0x54, 0x1a, 0x92, 0x73, 0x9e, 0x3c, 0x15, 0xaf, 0x5e,
	0x53, 0xd6, 0x50, 0x86, 0xb8, 0xb2, 0x19, 0x3d, 0xbf, 0xd8, 0x84, 0x4c,
	0xad, 0x20, 0x1d, 0xd2, 0x4f, 0x16, 0x23, 0x5f, 0x18, 0x18, 0xbb, 0x5a,
	0x75, 0xce, 0x2b, 0x44, 0x6e, 0xf3, 0x21, 0x19, 0x94, 0xe2, 0xe7, 0xc8,
	0x74, 0xfb, 0x04, 0xf2, 0x1b, 0x1a, 0x70, 0xc1, 0x01, 0xd6, 0x97, 0x3f,
	0x5c, 0xe9, 0xed, 0x1d, 0xb0, 0xe5, 0xf0, 0xd0, 0xa4, 0x33, 0xf1, 0xf6,
	0xf8, 0xb8, 0x3a, 0x4a, 0x18, 0x56, 0xe4, 0x3b, 0xf8, 0x20, 0xf5, 0x0b,
	0x50, 0x5b, 0x0c, 0x56, 0x53, 0xd5, 0xe6, 0xcb, 0x07, 0xb9, 0x24, 0x38,
	0x8a, 0x12, 0xce, 0xa7, 0x40, 0x00, 0x76, 0x03, 0x23, 0x97, 0xb5, 0xe8,
	0x0b, 0x64, 0xe9, 0xbe, 0x5e, 0xfa, 0x7e, 0xef, 0x4e, 0xf1, 0x6b, 0xbd,
	0x06, 0x17, 0xe2, 0xac, 0x67, 0xb7, 0xf9, 0x4c, 0xa3, 0xaf, 0x83, 0xc1,
	0xb2, 0x39, 0xed, 0x24, 0x2b, 0x84, 0xd9, 0x3a, 0x12, 0x10, 0x4b, 0xdd,
	0xc0, 0xd7, 0x18, 0xbb, 0x8a, 0xba, 0x7d, 0x71, 0x03, 0x48, 0xf2, 0x0e,
	0xee, 0xfe, 0x68, 0x0b,
};

static const uint8_t genrsa_pss_v15_sha256[] = {
	0x93, 0x6e, 0xc0, 0xcc, 0xfd, 0x1d, 0xc0, 0x71, 0x11, 0xb2, 0x54, 0x88,
	0xfa, 0x2c, 0xab, 0xe9, 0xad, 0x93, 0x41, 0x6a, 0x27, 0xda, 0x54, 0x71,
	0xdd, 0xfe, 0x53, 0x89, 0xf4, 0x16, 0xb8, 0x4d, 0x7b, 0xd5, 0x34, 0x23,
	0x0f, 0xe9, 0x01, 0x2e, 0x4e, 0x58, 0xa8, 0xc6, 0x3b, 0x42, 0x32, 0xd2,
	0x2d, 0x47, 0x06, 0x68, 0xa9, 0x37, 0xb8, 0x99, 0xd0, 0xb3, 0xc9, 0x4c,
	0xf5, 0x6a, 0x88, 0x55, 0x18, 0x38, 0x96, 0x4c, 0x56, 0xd3, 0xfa, 0xab,
	0xad, 0x79, 0xf8, 0x70, 0x2d, 0x5a, 0x2a, 0xe0, 0x27, 0x9f, 0x61, 0xf0,
	0x08, 0x84, 0xdb, 0x9a, 0x94, 0x44, 0xd8, 0x3d, 0x2e, 0xc3, 0x90, 0x33,
	0x4f, 0x73, 0xf3, 0x1f, 0x0a, 0x94, 0xec, 0x97, 0xf8, 0x29, 0x3e, 0xc6,
	0x81, 0x10, 0x0e, 0xbe, 0xc0, 0xc9, 0x8d, 0x49, 0xa7, 0xdd, 0x23, 0x91,
	0x40, 0x3c, 0x1e, 0x44, 0xab, 0x03, 0x5e, 0x9f, 0xad, 0x22, 0x08, 0x0b,
	0x29, 0x27, 0x15, 0xf7, 0x95, 0x8b, 0x5b, 0xac, 0x49, 0x58, 0x9d, 0x1a,
	0x1f, 0x88, 0x02, 0x8e, 0x68, 0x9e, 0x09, 0x15, 0x23, 0x37, 0x1e, 0xeb,
	0xfe, 0xea, 0x77, 0x53, 0xd0, 0xe5, 0x39, 0x11, 0x3d, 0xe4, 0xf0, 0xe8,
	0x3e, 0xbb, 0x75, 0x9b, 0x41, 0x5a, 0xcf, 0x81, 0xbf, 0xa4, 0x1e, 0x59,
	0x69, 0x41, 0x78, 0xbb, 0x4d, 0xcf, 0x6a, 0x7d, 0x89, 0xd2, 0x93, 0x10,
	0x24, 0xf0, 0x0b, 0xe6, 0xf0, 0x1d, 0x3f, 0xf9, 0xf1, 0xea, 0xf3, 0x01,
	0x59, 0x57, 0xc7, 0x8b, 0xb7, 0x6b, 0xb6, 0x28, 0x79, 0xb9, 0x16, 0x10,
	0xc2, 0x75, 0xdd, 0x00, 0xf0, 0x0b, 0x43, 0x9b, 0xa0, 0x89, 0x73, 0x18,
	0xfc, 0x09, 0xc0, 0xf3, 0x50, 0x09, 0xb5, 0x7e, 0x8b, 0xf5, 0xf0, 0x58,
	0xca, 0x0c, 0x47, 0xaa, 0xea, 0x0f, 0x08, 0xe9, 0x63, 0x08, 0x54, 0x93,
	0x80, 0xa1, 0x61, 0x1e,
};
static const struct {
	const char		*name;
	enum lws_genhash_types	hash;
	const uint8_t		*sig;
	size_t			sig_len;
} genrsa_pss_algs[] = {
	{ "PS256", LWS_GENHASH_TYPE_SHA256, genrsa_pss_sig_sha256,
					    sizeof(genrsa_pss_sig_sha256) },
	{ "PS384", LWS_GENHASH_TYPE_SHA384, genrsa_pss_sig_sha384,
					    sizeof(genrsa_pss_sig_sha384) },
	{ "PS512", LWS_GENHASH_TYPE_SHA512, genrsa_pss_sig_sha512,
					    sizeof(genrsa_pss_sig_sha512) },
};

static int
test_genrsa_pss_hash(enum lws_genhash_types type, const void *in, size_t len,
		     uint8_t *hash)
{
	struct lws_genhash_ctx gh;

	if (lws_genhash_init(&gh, type) ||
	    lws_genhash_update(&gh, in, len) ||
	    lws_genhash_destroy(&gh, hash))
		return 1;

	return 0;
}

static int
test_genrsa_pss(struct lws_context *context)
{
	struct lws_gencrypto_keyelem priv[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	struct lws_gencrypto_keyelem pub[LWS_GENCRYPTO_RSA_KEYEL_COUNT];
	uint8_t hash[LWS_GENHASH_LARGEST], sig[sizeof(genrsa_pss_n)];
	struct lws_genrsa_ctx priv_ctx, pub_ctx;
	size_t i, msg_len = strlen(genrsa_pss_msg);
	int n, ret = 1;

	memset(&priv_ctx, 0, sizeof(priv_ctx));
	memset(&pub_ctx, 0, sizeof(pub_ctx));
	memset(priv, 0, sizeof(priv));
	memset(pub, 0, sizeof(pub));

#define genrsa_pss_el(_idx, _arr) \
	priv[_idx].buf = (uint8_t *)(uintptr_t)_arr; \
	priv[_idx].len = (uint32_t)sizeof(_arr)

	genrsa_pss_el(LWS_GENCRYPTO_RSA_KEYEL_E,  genrsa_pss_e);
	genrsa_pss_el(LWS_GENCRYPTO_RSA_KEYEL_N,  genrsa_pss_n);
	genrsa_pss_el(LWS_GENCRYPTO_RSA_KEYEL_D,  genrsa_pss_d);
	genrsa_pss_el(LWS_GENCRYPTO_RSA_KEYEL_P,  genrsa_pss_p);
	genrsa_pss_el(LWS_GENCRYPTO_RSA_KEYEL_Q,  genrsa_pss_q);
	genrsa_pss_el(LWS_GENCRYPTO_RSA_KEYEL_DP, genrsa_pss_dp);
	genrsa_pss_el(LWS_GENCRYPTO_RSA_KEYEL_DQ, genrsa_pss_dq);
	genrsa_pss_el(LWS_GENCRYPTO_RSA_KEYEL_QI, genrsa_pss_qi);

#undef genrsa_pss_el

	test_genrsa_prepare_public_elements(pub, priv);

	for (i = 0; i < LWS_ARRAY_SIZE(genrsa_pss_algs); i++) {
		enum lws_genhash_types ht = genrsa_pss_algs[i].hash;
		const char *nm = genrsa_pss_algs[i].name;

		if (lws_genrsa_create(&priv_ctx, priv, context,
				      LGRSAM_PKCS1_OAEP_PSS,
				      LWS_GENHASH_TYPE_UNKNOWN) ||
		    lws_genrsa_create(&pub_ctx, pub, context,
				      LGRSAM_PKCS1_OAEP_PSS,
				      LWS_GENHASH_TYPE_UNKNOWN)) {
			lwsl_err("%s: %s: lws_genrsa_create failed\n",
				 __func__, nm);
			goto bail;
		}

		if (test_genrsa_pss_hash(ht, genrsa_pss_msg, msg_len, hash)) {
			lwsl_err("%s: %s: hash failed\n", __func__, nm);
			goto bail;
		}

		/* 1) sign with the private key, verify with the public one */

		n = lws_genrsa_hash_sign(&priv_ctx, hash, ht, sig, sizeof(sig));
		if (n < 0) {
			lwsl_err("%s: %s: sign failed\n", __func__, nm);
			goto bail;
		}

		if (lws_genrsa_hash_sig_verify(&pub_ctx, hash, ht, sig,
					       (size_t)n)) {
			lwsl_err("%s: %s: verify of our own signature failed\n",
				 __func__, nm);
			goto bail;
		}

		/* 2) a signature over the same key and message made elsewhere */

		if (lws_genrsa_hash_sig_verify(&pub_ctx, hash, ht,
					       genrsa_pss_algs[i].sig,
					       genrsa_pss_algs[i].sig_len)) {
			lwsl_err("%s: %s: known-good PSS vector rejected\n",
				 __func__, nm);
			goto bail;
		}

		/*
		 * 3) the same key and message signed PKCS#1 v1.5 with SHA-256
		 *    must not be accepted as a PSS signature (it is only a
		 *    SHA-256 signature, so it can only be offered to PS256)
		 */

		if (ht == LWS_GENHASH_TYPE_SHA256 &&
		    !lws_genrsa_hash_sig_verify(&pub_ctx, hash, ht,
						genrsa_pss_v15_sha256,
						sizeof(genrsa_pss_v15_sha256))) {
			lwsl_err("%s: %s: PKCS#1 v1.5 signature accepted as "
				 "PSS\n", __func__, nm);
			goto bail;
		}

		lws_genrsa_destroy(&pub_ctx);
		lws_genrsa_destroy(&priv_ctx);

		lwsl_info("%s: %s OK\n", __func__, nm);
	}

	ret = 0;

bail:
	lws_genrsa_destroy(&pub_ctx);
	lws_genrsa_destroy(&priv_ctx);

	return ret;
}

int
test_genrsa(struct lws_context *context)
{
#if !defined(GENRSA_HAS_PKCS1_DATAOPS) && !defined(GENRSA_HAS_OAEP) && \
    !defined(GENRSA_HAS_KEYGEN_SIGNVERIFY)
	lwsl_notice("%s: Skipping RSA data-op tests (unsupported on this "
		    "backend)\n", __func__);
#else
#if defined(GENRSA_HAS_PKCS1_DATAOPS)
	if (test_genrsa_roundtrips(context))
		goto bail;

	if (test_genrsa_fixed_vectors(context))
		goto bail;
#endif

#if defined(GENRSA_HAS_OAEP)
	if (test_genrsa_oaep_roundtrips(context))
		goto bail;
#endif

#if defined(GENRSA_HAS_KEYGEN_SIGNVERIFY)
	if (test_genrsa_recreate(context))
		goto bail;
#endif
#endif

	/* every backend must do RSA-PSS, it is what JWS PS256/384/512 is */

	if (test_genrsa_pss(context))
		goto bail;

	lwsl_notice("%s: selftest OK\n", __func__);

	return 0;

bail:
	lwsl_err("%s: selftest failed ++++++++++++++++++++\n", __func__);

	return 1;
}
